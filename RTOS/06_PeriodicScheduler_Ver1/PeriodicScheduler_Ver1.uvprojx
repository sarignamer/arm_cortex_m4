# Keil uVision project PeriodicScheduler_Ver1.uvprojx, settings and files
target STM32F411 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PeriodicScheduler_Ver1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group osKernel
    ./: osKernel.c osKernel.h osKernel.s
  group user
    ./: main.c
  group osBSP
    ./: STM32F4_RTOS_BSP.c STM32F4_RTOS_BSP.h
software components: CMSIS:CORE 5.2.0, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:ADC 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:Startup 2.6.2
